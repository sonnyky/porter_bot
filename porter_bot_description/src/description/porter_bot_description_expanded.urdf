Commit message: maybe this is more stable?

File: porter_bot_description/src/description/porter_bot_description_expanded.urdf (robot description, URDF)
Before this commit: robot porter_bot, 8 links, 7 joints
Links:
- link base_link: mass 15 -> None
