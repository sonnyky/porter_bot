Commit message: setup gazebo and control robot through ign bridge

File: src/porter_bot_description/src/description/porter_bot_description_expanded.urdf (robot description, URDF)
Before this commit: robot porter_bot, 8 links, 7 joints
Links:
- link base_link: mass None -> 15
